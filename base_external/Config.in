## base_external/package/raspi-theramin/Config.in
```kconfig
config BR2_PACKAGE_RASPI_THERAMIN
	bool "raspi-theramin"
	help
	  Includes the theramin executable
```
